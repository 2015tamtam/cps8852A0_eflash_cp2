# Keil uVision project CPS8852_eFlash_CP2.uvprojx, settings and files
target CPS8852_eFlash_CP2 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CPS8852_eFlash_CP2 +hex
  AfterMake: rename.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST,CORTEX_M0
  c include: ..\Inc\CMSIS;..\Inc\CPS8852_Series\driver;..\Inc\CPS8852_Series;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x1800
  memory RVCT9: RAM 0x20001800 size 0x800
  group Startup Files
    ../Src/CPS8852_Series/: startup_CM0.s system_CPS8852Series.c
  group Driver Files
    ../Src/CPS8852_Series/driver/: uart.c retarget.c
  group ISR
    ../Src/: isr.c
  group Variable
    ../Src/: variable.c
  group Application/Main
    ../Src/: main.c test_cp2.c eflash_cp.c
